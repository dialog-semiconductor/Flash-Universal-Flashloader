# Keil uVision project imxrt1060_adesto_fl.uvprojx, settings and files
target imxrt1060_adesto_fl (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.12.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: imxrt1060_adesto_fl +hex
  AfterMake: cmd.exe /C copy ".\Out\%L" ".\fl_package\MIMXRT106x_Adesto_16MB.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1062DVL6A
  c misc: --diag_suppress=61,66,1296,186
  c include: ..\..\..\..\adesto, ..\..\..\..\toolchains\keil, ..\al, ..\sdk
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Adesto
    ../../../../adesto/: adesto_detect.c adesto_drv.c
  group al
    ../al/: adesto_lut.c clock_config.c fhc.c sys_init.c
  group keil_fl
    ../../../../toolchains/keil/: FlashDev.c FlashPrg.c
  group sdk
    ../sdk/: fsl_clock.c fsl_common.c fsl_flexspi.c fsl_gpio.c system_MIMXRT1062.c
software components: CMSIS:CORE 5.3.0
