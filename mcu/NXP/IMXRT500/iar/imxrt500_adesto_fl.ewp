# IAR project imxrt500_adesto_fl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT595SFFOB_cm33
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../../adesto; ../al; ../sdk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.srec
  postbuild: cmd /c "copy Debug\EXE\$PROJ_FNAME$.out fl_package\FlashIMXRT500_EVK_Adesto.out"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: FlashIMXRT5xx_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6B
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  postbuild: cmd /c "copy Release\EXE\$PROJ_FNAME$.out fl_package\FlashIMXRT1050_EVK_Adesto.out"
  ILINK.IlinkIcfFile: C:\Users\eyal\Documents\FlashLoaders\Adesto-FL\mcus\NXP\IMXRT1050\iar\FlashIMXRT1050_RAM.icf
  group adesto
    ../../../../adesto/: adesto_detect.c adesto_drv.c
  group al
    ../al/: adesto_lut.c clock_config.c fhc.c sys_init.c
  group iar_fl
    ../../../../toolchains/iar/: flash_loader.c flash_loader_asm.s flash_loader_ram.c
  group sdk
    ../sdk/: fsl_clock.c fsl_common.c fsl_flexspi.c fsl_gpio.c fsl_power.c fsl_reset.c system_MIMXRT595S_cm33.c
