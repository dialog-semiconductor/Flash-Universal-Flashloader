<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\imxrt1050_adesto_fl.ewp</path>
    </project>
    <batchBuild />
</workspace>
