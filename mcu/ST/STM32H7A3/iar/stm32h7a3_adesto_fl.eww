<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm32h7a3_adesto_fl.ewp</path>
    </project>
    <batchBuild />
</workspace>
