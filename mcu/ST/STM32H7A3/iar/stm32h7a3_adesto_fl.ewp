# IAR project stm32h7a3_adesto_fl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7A3ZI ST STM32H7A3ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; STM32H7A3xxQ
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../../adesto; ../al; ../sdk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.srec
  postbuild: cmd /c "copy Debug\EXE\$PROJ_FNAME$.out fl_package\FlashSTM32H7Axxx_Adesto.out"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32h7a3_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32H7A3xxQ
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  postbuild: cmd /c "copy Release\EXE\$PROJ_FNAME$.out fl_package\FlashSTM32H7Axxx_Adesto.out"
  ILINK.IlinkIcfFile: C:\Users\ebarzila\Documents\FlashLoaders\Adesto-FL\mcus\ST\STM32H7A3\iar\stm32h7a3_RAM.icf
  group adesto
    ../../../../adesto/: adesto_detect.c adesto_drv.c
  group al
    ../al/: fhc.c fhc_defs.h sys_init.c system_stm32h7xx.c
  group iar_fl
    ../../../../toolchains/iar/: flash_loader.c flash_loader_asm.s flash_loader_ram.c
  group sdk
    ../sdk/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_flash.c stm32h7xx_hal_gpio.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c
