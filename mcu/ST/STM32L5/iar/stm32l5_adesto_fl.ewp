# IAR project stm32l5_adesto_fl.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32H7A3ZI ST STM32H7A3ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; STM32H7A3xxQ
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../../adesto; ../al; ../sdk
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.srec
  postbuild: cmd /c "copy Release\EXE\$PROJ_FNAME$.out fl_package\FlashSTM32H7Axxx_Adesto.out"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Users\eyal\Documents\FlashLoaders\Adesto-FL\mcus\ST\STM32H7A3\iar\stm32h7a3_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_STM32L5_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; STM32L552xx; STM32L5_EVAL
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  postbuild: cmd /c "copy Debug_STM32L5_EVAL\EXE\$PROJ_FNAME$.out fl_package\FlashSTM32L5xxx_Adesto.out"
  ILINK.IlinkIcfFile: stm32l552xx_sram.icf
configuration Debug_STM32L5_Nucleo_Quad (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; STM32L552xx; STM32L5_NUCLEO_QUAD_SHIELD
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  postbuild: cmd /c "copy Debug_STM32L5_Nucleo_Quad\EXE\$PROJ_FNAME$.out fl_package\FlashSTM32L5xxx_Nucleo_Quad_Adesto.out"
  ILINK.IlinkIcfFile: stm32l552xx_sram.icf
  group adesto
    ../../../../adesto/: adesto_detect.c adesto_drv.c
  group al
    ../al/: fhc.c fhc_defs.h sys_init.c system_stm32l5xx.c
  group iar_fl
    ../../../../toolchains/iar/: flash_loader.c flash_loader_asm.s flash_loader_ram.c
  group sdk
    ../sdk/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_flash.c stm32l5xx_hal_gpio.c stm32l5xx_hal_icache.c stm32l5xx_hal_ospi.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c
